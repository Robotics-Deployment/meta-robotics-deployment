# robotics-deployment-core-tests.bb

require recipes-core/images/robotics-deployment-core.bb
inherit testimage

