FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://netfilter.cfg"
